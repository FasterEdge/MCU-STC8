# Keil uVision project FasterEdge-MCU-STC8.uvproj, settings and files
target FasterEdge-MCU-STC8 (C51)
  device: STC8H8K64U Intel
  cpu: IRAM(0x0-0x7F) IRAM(0x80-0xFF) XRAM(0x0-0xFFFF) CODE(0x0-0xFFFF) CLOCK=12000000
  output: FasterEdge-MCU-STC8 +hex
  c define: STC8H8K64U
  c include: ..\Core;..\Inc;..\User;..\Ability;..\Data
  group Core
    ../Core/: fe.c fe_hmac_sha256.c
  group Ability
    ../Ability/: ability_base.c ability_role.c ability_time.c ability_onekey.c ability_serial.c ability_modbus.c
  group Data
    ../Data/: data_base.c data_config.c
  group User
    ../User/: main.c register.c fe_port.c
